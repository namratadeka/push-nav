Commit message: gen obs in a circle

File: push_policy/resources/simpleplane.urdf (robot description, URDF)
Before this commit: robot simpleplane, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=10 10 0.01; visual box size=10 10 0.01

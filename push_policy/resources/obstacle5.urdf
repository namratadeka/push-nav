Commit message: load bullet plane

File: push_policy/resources/obstacle5.urdf (robot description, URDF)
Before this commit: robot obstacle3, 1 links, 0 joints
Links:
- link base_link: geometry collision cylinder length=0.1 radius=0.4; visual cylinder length=0.1 radius=0.4
